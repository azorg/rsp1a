options:
  parameters:
    generate_options: qt_gui
    id: fm_radio_rtlsdr
    output_language: python
    realtime_scheduling: '1'
    title: FM radio based on RTL-SDR
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Audio gain
    start: '0'
    step: '.01'
    stop: '1'
    value: '1'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Central freq
    start: '87000000'
    step: '100000'
    stop: '110000000'
    value: '104000000'
  states: {}
- name: channel_freq
  id: variable_qtgui_range
  parameters:
    label: Channel freq
    start: '87000000'
    step: '100000'
    stop: '110000000'
    value: '104200000'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX gain
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1800e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    name: '"FFT"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"FFT"'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    bw0: samp_rate/2
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
